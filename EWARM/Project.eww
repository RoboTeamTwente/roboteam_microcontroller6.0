<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\top_board1.1_H7.ewp</path>
  </project>
  <batchBuild />
</workspace>
